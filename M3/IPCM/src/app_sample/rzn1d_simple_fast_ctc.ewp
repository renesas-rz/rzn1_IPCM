# IAR project rzn1d_simple_fast_ctc.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: R9A06G032_M3 Renesas R9A06G032_M3
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Normal.h
  General.CoreVariant: 38
  General.FPU2: 0
  ICCARM.CCDefines: BSP_PLAT_RZN1DDB; CORE_CM3; GOAL_CONFIG_IP_STATS=1
  ICCARM.IExtraOptions: --enum_is_int
  ICCARM.CCIncludePath2: inc; $PROJ_DIR$; src\asb; ..\fit_modules\r_timer_rzn1\src; ..\fit_modules\r_uart_rzn1; ..\fit_modules\r_uart_rzn1\src; ..\fit_modules\r_msebi_rzn1; ..\fit_modules\r_msebi_rzn1\src; ..\fit_modules\r_spi_rzn1; ..\fit_modules\r_spi_rzn1\src; ..\fit_modules\r_dma_rzn1; ..\fit_modules\r_dma_rzn1\src; ..\fit_modules\r_sdio_rzn1; ..\fit_modules\r_sdio_rzn1\src; ..\fit_modules\r_iomux_rzn1; ..\fit_modules\r_iomux_rzn1\src; ..\fit_modules\r_gpio_rzn1; ..\fit_modules\r_gpio_rzn1\src; ..\fit_modules\r_gpio_rzn1\src\targets\rzn1d; ..\fit_modules\r_bsp; ..\fit_modules\r_bsp\inc; ..\fit_modules\r_bsp\board\rzn1d-db; ..\fit_modules\r_bsp\mcu\all; ..\fit_modules\r_bsp\mcu\rzn1; ..\fit_modules\r_bsp\mcu\rzn1\cm3; ..\fit_modules\r_config; ..\fit_modules\r_qspi_rzn1; ..\fit_modules\r_qspi_rzn1\src; ..\fit_modules\r_wdt_rzn1; ..\fit_modules\r_wdt_rzn1\src; ..\fit_modules\r_iic_rzn1; ..\fit_modules\r_iic_rzn1\src; ..\fit_modules\r_usb_rzn1\r_usb_common_rzn1; ..\fit_modules\r_usb_rzn1\r_usb_common_rzn1\src; ..\fit_modules\r_usb_rzn1\r_usbf_basic_rzn1; ..\fit_modules\r_usb_rzn1\r_usbf_basic_rzn1\src; ..\fit_modules\r_usb_rzn1\r_usbf_cdc_rzn1; ..\fit_modules\r_usb_rzn1\r_usbf_cdc_rzn1\src; ..\fit_modules\r_usb_rzn1\r_usbh_basic_rzn1; ..\fit_modules\r_usb_rzn1\r_usbh_basic_rzn1\src; ..\fit_modules\r_usb_rzn1\r_usbh_cdc_rzn1; ..\fit_modules\r_usb_rzn1\r_usbh_cdc_rzn1\src; ..\fit_modules\r_usb_rzn1\r_usbh_hub_rzn1; ..\fit_modules\r_usb_rzn1\r_usbh_hub_rzn1\src; ..\fit_modules\r_gmac_rzn1; ..\fit_modules\r_gmac_rzn1\src; ..\fit_modules\r_adc_rzn1; ..\fit_modules\r_adc_rzn1\src; ..\fit_modules\r_can_rzn1; ..\fit_modules\r_can_rzn1\src; ..\fit_modules\r_gmac_rzn1\src; ..\fit_modules\r_gmac_rzn1; ..\fit_modules\r_a5psw_rzn1; ..\fit_modules\r_a5psw_rzn1\src; ..\lwip\src\include; ..\lwip\port; ..\..\src\hw_func; $EW_DIR$\arm\inc\Renesas
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 2
  ICCARM.IccLang: 2
  OBJCOPY.OOCOutputFile: rzn1d_simple_fast_ctc.bin
  ILINK.IlinkOutputFile: $PROJ_FNAME$.out
  ILINK.IlinkIcfFile: RZN1_CM3.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: NDEBUG
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  group (top)
    ./: readme.txt
  group App
    ../fit_modules/r_iomux_rzn1/src/: pinmux.c r_iomux_rzn1_if.c
    ../fit_modules/r_bsp/mcu/rzn1/: r_sysctrl_rzn1_if.c
    ../fit_modules/r_bsp/board/rzn1d-db/: rzn1_dma_mux.c
    src/: sample_app.c
  group Drivers/DMA
    ../fit_modules/r_dma_rzn1/src/: r_dma_rzn1.c r_dma_rzn1_if.c
  group Drivers/GPIO
    ../fit_modules/r_gpio_rzn1/src/: r_gpio_rzn1.c r_gpio_rzn1_if.c
  group Drivers/TIMER
    ../fit_modules/r_timer_rzn1/src/: r_timer_rzn1_if.c timer.c
  group Drivers/UART
    ../fit_modules/r_uart_rzn1/src/: r_uart_rzn1.c r_uart_rzn1_if.c
  group HWOS
    src/: kernel_cfg.c
  group Lib
    ../lib/: libos.a
  group Startup
    ../fit_modules/r_bsp/board/rzn1l-db/: hwsetup_l.c
  group Startup/CM3
    ../fit_modules/r_bsp/mcu/rzn1/cm3/: mcu_interrupts.c start_m3.c system_RZN1.c
  group Startup/CM3/NVIC
    ../fit_modules/r_bsp/mcu/rzn1/cm3/: vector_table.c
  group Startup/DDR
    ../fit_modules/r_bsp/mcu/rzn1/ddr/: ddr_ctrl.c ddr_init.c
  group unused
    ../fit_modules/r_iomux_rzn1/src/: clock.c
    ../hw_func/eth/: eth_hwfnc.c
  group unused/A5PSW
    ../fit_modules/r_a5psw_rzn1/src/: r_a5psw_rzn1.c
  group unused/USB
    ../fit_modules/r_usb_rzn1/r_usb_common_rzn1/src/: r_usb_rzn1_if.c
