# IAR project FLASH_rzn_lwip_socket_gmac.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: R9A06G034_M3 Renesas R9A06G034_M3
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Normal.h
  General.CoreVariant: 38
  General.FPU2: 0
  ICCARM.CCDefines: BSP_PLAT_RZN1LDB; CORE_CM3; RZN1L_BOOT_FROM_ROM=1
  ICCARM.IExtraOptions: --enum_is_int
  ICCARM.CCIncludePath2: inc; $PROJ_DIR$; ..\fit_modules\r_timer_rzn1\src; ..\fit_modules\r_uart_rzn1; ..\fit_modules\r_uart_rzn1\src; ..\fit_modules\r_msebi_rzn1; ..\fit_modules\r_msebi_rzn1\src; ..\fit_modules\r_spi_rzn1; ..\fit_modules\r_spi_rzn1\src; ..\fit_modules\r_dma_rzn1; ..\fit_modules\r_dma_rzn1\src; ..\fit_modules\r_sdio_rzn1; ..\fit_modules\r_sdio_rzn1\src; ..\fit_modules\r_iomux_rzn1; ..\fit_modules\r_iomux_rzn1\src; ..\fit_modules\r_gpio_rzn1; ..\fit_modules\r_gpio_rzn1\src; ..\fit_modules\r_gpio_rzn1\src\targets\rzn1l; ..\fit_modules\r_bsp; ..\fit_modules\r_bsp\inc; ..\fit_modules\r_bsp\board\rzn1l-db; ..\fit_modules\r_bsp\mcu\all; ..\fit_modules\r_bsp\mcu\rzn1; ..\fit_modules\r_bsp\mcu\rzn1\cm3; ..\fit_modules\r_config; ..\fit_modules\r_qspi_rzn1; ..\fit_modules\r_qspi_rzn1\src; ..\fit_modules\r_wdt_rzn1; ..\fit_modules\r_wdt_rzn1\src; ..\fit_modules\r_iic_rzn1; ..\fit_modules\r_iic_rzn1\src; ..\fit_modules\r_usb_rzn1\r_usb_common_rzn1; ..\fit_modules\r_usb_rzn1\r_usb_common_rzn1\src; ..\fit_modules\r_usb_rzn1\r_usbf_basic_rzn1; ..\fit_modules\r_usb_rzn1\r_usbf_basic_rzn1\src; ..\fit_modules\r_usb_rzn1\r_usbf_cdc_rzn1; ..\fit_modules\r_usb_rzn1\r_usbf_cdc_rzn1\src; ..\fit_modules\r_usb_rzn1\r_usbh_basic_rzn1; ..\fit_modules\r_usb_rzn1\r_usbh_basic_rzn1\src; ..\fit_modules\r_usb_rzn1\r_usbh_cdc_rzn1; ..\fit_modules\r_usb_rzn1\r_usbh_cdc_rzn1\src; ..\fit_modules\r_usb_rzn1\r_usbh_hub_rzn1; ..\fit_modules\r_usb_rzn1\r_usbh_hub_rzn1\src; ..\fit_modules\r_gmac_rzn1; ..\fit_modules\r_gmac_rzn1\src; ..\fit_modules\r_adc_rzn1; ..\fit_modules\r_adc_rzn1\src; ..\fit_modules\r_can_rzn1; ..\fit_modules\r_can_rzn1\src; ..\fit_modules\r_gmac_rzn1\src; ..\fit_modules\r_gmac_rzn1; ..\fit_modules\r_a5psw_rzn1; ..\fit_modules\r_a5psw_rzn1\src; ..\lwip\src\include; ..\lwip\port; C:\projects\HWI\bsd_lwip_port\src\hw_func; $EW_DIR$\arm\inc\Renesas; C:\projects\HWI\bsd_lwip_port\src\app_sample\src\asb
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 2
  ICCARM.IccLang: 2
  OBJCOPY.OOCOutputFile: FLASH_rzn_lwip_socket_gmac.bin
  prebuild: build.cmd "$PROJ_DIR$" "$DATE$" "$USER_NAME$"  "$EW_DIR$"
  ILINK.IlinkOutputFile: $PROJ_FNAME$.out
  ILINK.IlinkIcfFile: IAR\rom_spi.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: NDEBUG
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  group (top)
    ./: readme.txt
  group App
    src/asb/: asb_low_level_init.c prim.c version.c
    ../fit_modules/r_iomux_rzn1/src/: clock.c pinmux.c r_iomux_rzn1_if.c
    ../hw_func/eth/: eth_hwfnc.c
    ../fit_modules/r_bsp/mcu/rzn1/: r_sysctrl_rzn1_if.c
    ../fit_modules/r_bsp/board/rzn1d-db/: rzn1_dma_mux.c
    src/: sample_app.c serial_log.c timers.c
  group asb_src
    ../../asb_src/src/: AD5660.cpp AD5660.hpp ADS1256.cpp ADS1256.hpp ASBConfig.cpp ASBConfig.hpp ASBRTTask.hpp BufferPool.hpp Constants.hpp ErrorCode.hpp GFCValve.cpp GFCValve.hpp main.cpp MuxConfig.hpp PIDHandler.cpp PIDHandler.hpp PositionControlTask.cpp PositionControlTask.hpp SensorCollectorTask.cpp SensorCollectorTask.hpp SPI.cpp SPI.hpp SyncObject.hpp TaskMessages.hpp UDPCollector.hpp UDPReceiveTask.cpp UDPReceiveTask.hpp UDPTransmitTask.cpp UDPTransmitTask.hpp
  group Drivers/A5PSW
    ../fit_modules/r_a5psw_rzn1/src/: r_a5psw_rzn1.c
  group Drivers/ADC
    ../fit_modules/r_adc_rzn1/src/: r_adc_rzn1.c r_adc_rzn1_if.c
  group Drivers/CAN
    ../fit_modules/r_can_rzn1/src/: r_can_rzn1.c r_can_rzn1_if.c
  group Drivers/DMA
    ../fit_modules/r_dma_rzn1/src/: r_dma_rzn1.c r_dma_rzn1_if.c
  group Drivers/GMAC
    ../fit_modules/r_gmac_rzn1/src/: r_gmac_rzn1.c r_gmac_rzn1_if.c r_phy_rzn1.c
  group Drivers/GPIO
    ../fit_modules/r_gpio_rzn1/src/: r_gpio_rzn1.c r_gpio_rzn1_if.c
  group Drivers/I2C
    ../fit_modules/r_iic_rzn1/src/: r_i2c_rzn1.c r_i2c_rzn1.h r_i2c_rzn1_if.c
  group Drivers/MSEBI
    ../fit_modules/r_msebi_rzn1/src/: r_msebi_rzn1.c r_msebi_rzn1_if.c
  group Drivers/QSPI
    ../fit_modules/r_qspi_rzn1/src/: r_qspi_rzn1.c r_qspi_rzn1_if.c
  group Drivers/SDIO
    ../fit_modules/r_sdio_rzn1/src/: r_sdio_rzn1.c r_sdio_rzn1_if.c r_sdio_rzn1_pl.c
  group Drivers/SPI
    ../fit_modules/r_spi_rzn1/src/: r_spi_rzn1.c r_spi_rzn1_if.c
  group Drivers/TIMER
    ../fit_modules/r_timer_rzn1/src/: r_timer_rzn1_if.c timer.c
  group Drivers/UART
    ../fit_modules/r_uart_rzn1/src/: r_uart_rzn1.c r_uart_rzn1_if.c
  group Drivers/USB/Common
    ../fit_modules/r_usb_rzn1/r_usb_common_rzn1/src/: r_usb_rzn1_if.c
  group Drivers/USB/Function/USB_basic
    ../fit_modules/r_usb_rzn1/r_usbf_basic_rzn1/src/: r_usbf_basic_rzn1_if.c r_usbf_cdataio.c r_usbf_controlrw.c r_usbf_core.c r_usbf_driver.c r_usbf_hal.c
  group Drivers/USB/Function/USB_cdc
    ../fit_modules/r_usb_rzn1/r_usbf_cdc_rzn1/src/: r_usb_pcdc_api.c r_usb_pcdc_driver.c
  group Drivers/USB/Host/basic
    ../fit_modules/r_usb_rzn1/r_usbh_basic_rzn1/src/: r_usb_cscheduler.c r_usb_hDriver.c r_usb_hdriverapi.c r_usb_hEhciMain.c r_usb_hEhciMemory.c r_usb_hEhciTransfer.c r_usb_hHci.c r_usb_hManager.c r_usb_hOhciMain.c r_usb_hOhciMemory.c r_usb_hOhciTransfer.c
  group Drivers/USB/Host/hcdc
    ../fit_modules/r_usb_rzn1/r_usbh_cdc_rzn1/src/: r_usb_hcdc_api.c r_usb_hcdc_driver.c r_usb_hcdc_rzn1_if.c
  group Drivers/USB/Host/hub
    ../fit_modules/r_usb_rzn1/r_usbh_hub_rzn1/src/: r_usb_hhub_rzn1_if.c
  group Drivers/WDT
    ../fit_modules/r_wdt_rzn1/src/: r_wdt_rzn1.c r_wdt_rzn1_if.c
  group HWOS
    src/: kernel_cfg.c
  group Lib
    ../lib/: libos.a
  group Lwip/src/api
    ../lwip/src/api/: api_lib.c api_msg.c err.c if_api.c netbuf.c netdb.c netifapi.c sockets.c tcpip.c
  group Lwip/src/core
    ../lwip/src/core/: def.c dns.c inet_chksum.c init.c ip.c mem.c memp.c netif.c pbuf.c raw.c stats.c sys.c tcp.c tcp_in.c tcp_out.c timeouts.c udp.c
  group Lwip/src/core/ipv4
    ../lwip/src/core/ipv4/: etharp.c icmp.c igmp.c ip4.c ip4_addr.c ip4_frag.c
  group Lwip/src/include/lwip
    ../lwip/src/include/lwip/: altcp.h altcp_tcp.h altcp_tls.h api.h arch.h autoip.h debug.h def.h dhcp.h dhcp6.h dns.h err.h errno.h etharp.h ethip6.h icmp.h icmp6.h if_api.h igmp.h inet.h inet_chksum.h init.h ip.h ip4.h ip4_addr.h ip4_frag.h ip6.h ip6_addr.h ip6_frag.h ip6_zone.h ip_addr.h mem.h memp.h mld6.h nd6.h netbuf.h netdb.h netif.h netifapi.h opt.h pbuf.h raw.h sio.h snmp.h sockets.h stats.h sys.h tcp.h tcpbase.h tcpip.h timeouts.h udp.h
  group Lwip/src/include/lwip/priv
    ../lwip/src/include/lwip/priv/: altcp_priv.h api_msg.h memp_priv.h memp_std.h nd6_priv.h sockets_priv.h tcp_priv.h tcpip_priv.h
  group Lwip/src/include/lwip/prot
    ../lwip/src/include/lwip/prot/: autoip.h dhcp.h dns.h etharp.h ethernet.h icmp.h icmp6.h igmp.h ip.h ip4.h ip6.h mld6.h nd6.h tcp.h udp.h
  group Lwip/src/include/netif
    ../lwip/src/include/netif/: etharp.h ethernet.h
  group Lwip/src/netif
    ../lwip/src/netif/: ethernet.c ethernetif.c
  group Lwip/src/port
    ../lwip/port/: sys_arch.c
  group Startup
    ../fit_modules/r_bsp/board/rzn1l-db/: hwsetup_l.c
  group Startup/CM3
    ../fit_modules/r_bsp/mcu/rzn1/cm3/: mcu_interrupts.c start_m3.c system_RZN1.c
  group Startup/CM3/NVIC
    ../fit_modules/r_bsp/mcu/rzn1/cm3/: vector_table.c
